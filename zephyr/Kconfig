## zephyr/Kconfig
```kconfig
config OPENBMC_PHOSPHOR_OBJMGR
    bool "openbmc phosphor object manager"
    select TINYXML2
```
